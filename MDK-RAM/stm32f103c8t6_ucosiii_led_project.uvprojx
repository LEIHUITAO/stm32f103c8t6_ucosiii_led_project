# Keil uVision project stm32f103c8t6_ucosiii_led_project.uvprojx, settings and files
target STM32F103C8T6_UCOS_LED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6_ucosiii_led_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Template;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\include;..\ucosiii\uc-bsp;..\ucosiii\uc-config;..\ucosiii\uc-cpu;..\ucosiii\uc-lib;..\ucosiii\ucos-iii\Source;..\ucosiii\ucos-iii\Ports\ARM-Cortex-M3\Generic\RealView;..\ucosiii\uc-cpu\ARM-Cortex-M3\RealView;..\ucosiii\uc-lib\Ports\ARM-Cortex-M3\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../STM32F10x_StdPeriph_Template/: main.c stm32f10x_it.c system_stm32f10x.c
  group startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group cmsis
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group source
    ../source/: led.c systick.c uart.c key.c
  group library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group uc-bsp
    ../ucosiii/uc-bsp/: bsp.c
  group uc-config
    ../ucosiii/uc-config/: os_app_hooks.c
  group uc-cpu
    ../ucosiii/uc-cpu/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ../ucosiii/uc-cpu/: cpu_core.c
  group uc-lib
    ../ucosiii/uc-lib/: lib_ascii.c lib_math.c lib_str.c lib_mem.c
    ../ucosiii/uc-lib/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group ucos_core
    ../ucosiii/ucos-iii/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uc-port
    ../ucosiii/ucos-iii/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
